# Keil uVision project max32550_bootloader.uvproj, settings and files
target max32550_bootloader (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: max32550_bootloader
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=3 wLevel=2
  c define: __RTX, TARGET_MAX32550, BOARD_MAX32600
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_Maxim\TARGET_MAX32550\Include;..\..\..\shared\rtos
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\max32550_bootloader.sct
  link misc: --entry=Reset_Handler
  group CMSIS
    ../../../shared/cmsis/TARGET_Maxim/TARGET_MAX32550/Source/: system_max32550.c default_vectors.c
    ../../../shared/cmsis/TARGET_Maxim/TARGET_MAX32550/Source/ARM/: startup_max32550.S callSystemInit.c
  group Common
    ../../Common/src/: flash_svc.c main.c RTX_Config.c SVC_Table.s usbd_user_msc.c version.c usb_config.c
  group HAL
    ../../hal/TARGET_Maxim/TARGET_MAX32550/: flash_hal.c read_uid.c gpio.c vector_table.c retarget.c usbd.c
  group USBStack
    ../../../shared/USBStack/SRC/: usbd_core.c usbd_core_msc.c usbd_msc.c
  group RTX
    ../../../shared/rtos/: HAL_CM3.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
target max32550_evkit_bootloader (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: max32550_evkit_bootloader
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  c flags: Optim=3 wLevel=2
  c define: __RTX, TARGET_MAX32550, BOARD_MAX32600, TARGET_MAX32550_EVKIT
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\max32550_evkit_bootloader.sct
  link misc: --entry=Reset_Handler
