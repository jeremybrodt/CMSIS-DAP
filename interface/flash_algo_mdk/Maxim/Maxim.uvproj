# Keil uVision project Maxim.uvproj, settings and files
target MAX32600 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: MAX32600
  c flags: Optim=1 wLevel=2
  c define: MAX32600
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target MAX32550 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: MAX32550
  c flags: Optim=1 wLevel=2
  c define: MAX32550
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
