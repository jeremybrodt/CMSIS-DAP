# Keil uVision project max32550_interface.uvproj, settings and files
target max32550_maxwsnenv_if (ARM-ADS)
  device: max32550 Maxim Integrated
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") IRAM(0x20000000-0x2003FFFF) IROM(0x10000000-0x100FFFFF) ESEL ELITTLE
  output: max32550_maxwsnenv_if
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1
  c define: TARGET_MAX32550, __RTX, DBG_MAXIM, BOARD_MAXWSNENV
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\target\hal\DBG_Maxim;..\..\interface\hal\TARGET_Maxim\TARGET_MAX32550;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_Maxim\TARGET_MAX32550\Include;..\..\..\shared\rtos;..\..\flash_algo_mdk\Maxim
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\max32550_mbed_if.sct
  link misc: --entry=Reset_Handler
  group CMSIS
    ../../../shared/cmsis/TARGET_Maxim/TARGET_MAX32550/Source/ARM/: startup_max32550.S callSystemInit.c
    ../../../shared/cmsis/TARGET_Maxim/TARGET_MAX32550/Source/: default_vectors.c system_max32550.c
  group Common
    ../../Common/src/: board.c DAP.c JTAG_DP.c main.c RTX_Config.c semihost.c serial.c usb_config.c usbd_user_cdc_acm.c usbd_user_hid.c SW_DP.c version.c swd_host.c usbd_user_msc.c jtag_host.c
  group HAL-Interface
    ../../interface/hal/TARGET_Maxim/TARGET_MAX32550/: DAP_config.h gpio.c read_uid.c retarget.c uart.c usbd.c board_maxim.c
  group HAL-Target-Maxim
    ../../target/hal/DBG_Maxim/: target_reset.c target_flash.c target_vendor.c
  group RTX
    ../../../shared/rtos/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c HAL_CM3.c
  group USBStack
    ../../../shared/USBStack/SRC/: usbd_cdc_acm.c usbd_core.c usbd_core_cdc.c usbd_core_hid.c usbd_hid.c usbd_core_msc.c usbd_msc.c
target max32550_evkit_if (ARM-ADS)
  device: max32550 Maxim Integrated
  cpu: as above
  output: max32550_evkit_if
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1
  c define: TARGET_MAX32550, TARGET_MAX32550_EVKIT, __RTX, DBG_MAXIM, BOARD_MAXWSNENV
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\max32550_if.sct
  link misc: --entry=Reset_Handler
target max32550_max32600mbed_if (ARM-ADS)
  device: max32550 Maxim Integrated
  cpu: as above
  output: \max32550_max32600mbed_if
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1
  c define: TARGET_MAX32550, __RTX, DBG_MAXIM, BOARD_MAX32600MBED
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\max32550_mbed_if.sct
  link misc: --entry=Reset_Handler
